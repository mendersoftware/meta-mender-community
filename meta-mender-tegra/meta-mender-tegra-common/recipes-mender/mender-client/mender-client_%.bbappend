require mender-tegra.inc

RDEPENDS:${PN} += "${EXTRADEPS}"