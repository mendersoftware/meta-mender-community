FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Enable-runtime-access-to-KernelCommandLine-efivar.patch;patchdir=../edk2-nvidia"