do_image_mender[noexec]="1"
do_image_sdimg[noexec]="1"
