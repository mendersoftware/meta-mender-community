FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
RDEPENDS:${PN} += "tegra-redundant-boot-nvbootctrl"
