PACKAGECONFIG:append = " machine-id"
