inherit image_types_mender_tegra
