RDEPENDS:${PN}:remove = "tegra-redundant-boot"
