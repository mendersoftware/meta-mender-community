# patches applied in upstream v0.2 as of 86bd30a14e153a18f670b25708795253d8736f0f
SRC_URI_remove = "file://0001-Restore-ability-to-feed-script-file-via-stdin-using-.patch \
    file://0002-ubi-write-fix-invalid-envsize-ptr-to-UBI_IOCVOLUP.patch can be reverse-applied \
"
