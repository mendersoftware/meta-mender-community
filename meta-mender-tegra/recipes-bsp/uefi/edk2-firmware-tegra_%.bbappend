
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0007-runtime-access-for-KernelCommandLine-efivar.patch;patchdir=.."
SRC_URI += "file://0008-enable-rootfs-redundancy.patch;patchdir=.."


