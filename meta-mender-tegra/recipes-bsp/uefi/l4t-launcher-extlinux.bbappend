UBOOT_EXTLINUX_FDT:jetson-orin-nano-devkit ?= "/boot/${DTBFILE}"
