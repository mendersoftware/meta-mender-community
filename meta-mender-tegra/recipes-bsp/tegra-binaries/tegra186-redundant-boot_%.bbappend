RDEPENDS_${PN} += "redundant-boot-overrides"

