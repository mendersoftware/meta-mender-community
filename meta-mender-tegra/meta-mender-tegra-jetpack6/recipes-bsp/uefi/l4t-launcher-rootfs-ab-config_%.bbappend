FILESEXTRAPATHS:prepend := "${THISDIR}/files:"