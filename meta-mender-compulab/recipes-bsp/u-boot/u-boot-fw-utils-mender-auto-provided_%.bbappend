require u-boot-mender-compulab.inc
