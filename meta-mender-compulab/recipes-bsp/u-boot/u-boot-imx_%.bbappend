require recipes-bsp/u-boot/u-boot-mender.inc
require u-boot-mender-compulab.inc
