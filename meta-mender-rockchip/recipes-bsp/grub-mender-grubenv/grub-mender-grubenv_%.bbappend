FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_tinker-rk3288 = " file://02_tinkerboard_console_grub.cfg;subdir=git"
