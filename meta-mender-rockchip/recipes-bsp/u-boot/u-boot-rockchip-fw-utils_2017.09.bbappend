require u-boot-rockchip-mender.inc
require recipes-bsp/u-boot/u-boot-fw-utils-mender.inc
