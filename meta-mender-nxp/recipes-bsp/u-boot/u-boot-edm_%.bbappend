require u-boot-mender-edm.inc
