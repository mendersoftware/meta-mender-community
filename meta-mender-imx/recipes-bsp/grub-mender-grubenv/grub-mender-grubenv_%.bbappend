FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_imx8mnevk = " file://02_console_grub.cfg;subdir=git"
