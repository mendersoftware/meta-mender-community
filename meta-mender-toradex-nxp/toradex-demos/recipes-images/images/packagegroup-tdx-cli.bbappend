RRECOMMENDS:packagegroup-base-tdx-cli:remove_mender-grub = "\
    u-boot-fw-utils \
"
