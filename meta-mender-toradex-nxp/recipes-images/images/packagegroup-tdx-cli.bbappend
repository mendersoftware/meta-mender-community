RRECOMMENDS_packagegroup-base-tdx-cli_remove_mender-grub = "\
    u-boot-fw-utils \
"
