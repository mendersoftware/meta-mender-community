FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_colibri-imx7-mender = " file://0001-Fix-capacitive-touch-for-7inch-display-with-Aster-ca.patch"
