SRC_URI:imx8mm-var-dart = "git://github.com/nxp-imx/imx-mkimage.git;protocol=https;branch=${SRCBRANCH} \
	file://0001-iMX8M-soc.mak-use-native-mkimage-from-sysroot.patch \
"
