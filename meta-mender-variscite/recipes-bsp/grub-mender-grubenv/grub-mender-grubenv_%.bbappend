FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_imx6ul-var-dart = " file://02_variscite_console_grub.cfg;subdir=git"
SRC_URI_append_imx8mm-var-dart = " file://02_variscite_console_grub.cfg;subdir=git"
SRC_URI_append_imx8mn-var-som = " file://02_variscite_console_grub.cfg;subdir=git"
