require u-boot-r8a7796.inc
