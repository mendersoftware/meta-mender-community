FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-aliases-for-mmc0-and-mmc-so-sdcard-and-emmc-don-.patch"

