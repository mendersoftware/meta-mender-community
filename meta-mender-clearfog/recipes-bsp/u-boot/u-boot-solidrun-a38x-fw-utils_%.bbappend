require recipes-bsp/u-boot/u-boot-solidrun-a38x-mender.inc
require recipes-bsp/u-boot/u-boot-fw-utils-mender.inc

