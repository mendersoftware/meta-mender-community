require recipes-bsp/u-boot/u-boot-solidrun-a38x-mender.inc
require recipes-bsp/u-boot/u-boot-mender.inc

MENDER_UBOOT_AUTO_CONFIGURE = "0"

