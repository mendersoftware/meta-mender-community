COMPATIBLE_MACHINE:raspberrypi5 = "(.*)"
